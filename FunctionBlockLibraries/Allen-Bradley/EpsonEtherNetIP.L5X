(* Logix 5000 Module export Epson; software revision 30.01 *)

MODULES
   Epson : ETHERNET-MODULE (Ethernet 192.168.0.5, rev 1.1, Output RPI 10 ms)
END_MODULES
